## boards/shields/eyelash_oled/Kconfig.shield
```kconfig
# SPDX-License-Identifier: MIT

config SHIELD_EYELASH_OLED
    def_bool $(shields_list_contains,eyelash_oled)
```
